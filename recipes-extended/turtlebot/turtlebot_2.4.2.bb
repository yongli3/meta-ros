DESCRIPTION = "The turtlebot meta package provides all the basic drivers for running and using a TurtleBot."
HOMEPAGE = "http://ros.org/wiki/turtlebot"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=d566ef916e9dedc494f5f793a6690ba5"

require turtlebot.inc
