DESCRIPTION = "turtlebot_bringup provides roslaunch scripts for starting the TurtleBot base functionality."
HOMEPAGE = "http://ros.org/wiki/turtlebot_bringup"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

require turtlebot.inc

DEPENDS = "kobuki-node "