DESCRIPTION = "Simple scripts which help utilise, monitor, interact with computer \
     hardware abstracted by a linux OS." 
HOMEPAGE = "http://ros.org/wiki/linux_hardware"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=6;endline=6;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = " roscpp diagnostic-msgs   message-generation  std-msgs "

require turtlebot.inc
