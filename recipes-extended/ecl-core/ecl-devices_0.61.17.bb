DESCRIPTION = "ROS nodelet for Kobuki: ROS wrapper for the Kobuki driver."
HOMEPAGE = "https://github.com/yujinrobot/kobuki/issues"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS ="catkin ecl-license ecl-build ecl-config ecl-errors ecl-mpl ecl-type-traits ecl-utilities ecl-containers ecl-threads"
require ecl-core.inc
